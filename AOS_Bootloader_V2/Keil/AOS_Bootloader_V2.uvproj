# Keil uVision project AOS_Bootloader_V2.uvproj, settings and files
target AOS_Bootloader_LDROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: AOS_Bootloader_LDROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\M480BSP\Library\Device\Nuvoton\M480\Include;..\..\M480BSP\Library\CMSIS\Include;..\..\M480BSP\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../M480BSP/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../M480BSP/Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c
  group Library
    ../../M480BSP/Library/StdDriver/src/: retarget.c clk.c uart.c fmc.c sys.c spim.c
target AOS_Bootloader_Cloner (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: as above
  output: AOS_Bootloader_Cloner
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DEF_CLONER=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x7c000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\AOS_Bootloader_Cloner.sct
  link misc: as above
