LOAD_ROM_1  0x7C000
{
	AOS_Bootloader_Cloner.bin 0x7C000
	{
		startup_M480.o (RESET, +FIRST)
		*.o (+RO)
	}
	SRAM  0x20000000 0x20000
	{
		* (+RW, +ZI)
	}
}